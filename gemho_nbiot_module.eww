<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gemho_nbiot_module.ewp</path>
    </project>
    <batchBuild />
</workspace>
